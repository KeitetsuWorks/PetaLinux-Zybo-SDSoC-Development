SRC_URI += "file://user_2018-09-01-09-01-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

